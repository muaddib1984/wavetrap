options:
  parameters:
    author: Muad'Dib
    generate_options: qt_gui
    id: uhd_wavetrap
    output_language: python
    title: WAVETRAP PUSH-BUTTON RF RECORDER
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,2,1,1
    label: Bandwidth
    start: 200e3
    step: 1e6
    stop: 56e6
    value: samp_rate*.8
  states: {}
- name: filename
  id: variable
  parameters:
    comment: |-
      creates full path to IQ recording
      and adds timestamp and the 
      'note' variable to the filename
    value: rootdir+record_file_path+note+"_"+str(int(freq))+"Hz_"+str(int(samp_rate))+"sps_"+str(gain)+"dB_"
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1630e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,0,1,1
    label: RX Gain
    start: '0'
    step: '1'
    stop: '89.0'
    value: '50.0'
  states: {}
- name: note
  id: variable_qtgui_entry
  parameters:
    gui_hint: tabs@0:1,1,1,2
    label: RECORDING NOTE (press enter to update)
    type: string
    value: RECORDING_NOTE
  states: {}
- name: rec_button
  id: variable_qtgui_push_button
  parameters:
    gui_hint: tabs@0:1,3,1,1
    label: RECORD
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: record_file_path
  id: variable
  parameters:
    comment: set path to IQ recording directory
    value: '"data/"'
  states: {}
- name: rootdir
  id: variable
  parameters:
    comment: defaults to your users home directory
    value: str(os.path.expanduser("~")+"/")
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,1,1,1
    label: sample_rate
    start: 200e3
    step: 1e6
    stop: 56e6
    value: 2e6
  states: {}
- name: timestamp
  id: variable
  parameters:
    comment: |-
      gets system time and
      applies string formatting
    value: datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S')
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename+str(datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S'))+".cfile" if rec_button == 1 else "/dev/null"
    type: complex
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: samp_rate
    gui_hint: tabs@0:2,0,5,4
  states: {}
- name: import_datetime
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_time
  id: import
  parameters:
    imports: import time
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tabs@0:1,0,1,1
    key: freq
    label: Msg-based input
    type: float
    value: 852e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '8192'
    gui_hint: tabs@0:2,0,5,4
    showports: 'True'
    type: complex
    update_time: '0.05'
  states: {state: disabled}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: tabs@0:0,3,1,1
    label: '"RED=RECORDING"'
    offColor: green
    onColor: red
    position: '2'
    state: True if rec_button == 1 else False
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,7,4
    label0: Tab 0
    num_tabs: '1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    bw0: bandwidth
    center_freq0: freq
    clock_source0: internal
    gain0: gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5000
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}

connections:
- [fosphor_qt_sink_c_0, freq, qtgui_edit_box_msg_0_0, val]
- [qtgui_edit_box_msg_0_0, msg, blocks_msgpair_to_var_0, inpair]
- [qtgui_edit_box_msg_0_0, msg, uhd_usrp_source_0, command]
- [qtgui_freq_sink_x_0, freq, qtgui_edit_box_msg_0_0, val]
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', fosphor_qt_sink_c_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
