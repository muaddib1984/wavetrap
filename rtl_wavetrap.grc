options:
  parameters:
    author: Muad'Dib
    generate_options: qt_gui
    id: rtl_wavetrap
    output_language: python
    title: WAVETRAP PUSH-BUTTON RF RECORDER
  states: {}

blocks:
- name: filename
  id: variable
  parameters:
    comment: |-
      creates full path to IQ recording
      and adds timestamp and the 
      'note' variable to the filename
    value: rootdir+record_file_path+note+"_"+str(int(freq))+"Hz_"+str(int(gui_samp_rate))+"sps_"+str(gui_gain)+"dB_"
  states: {}
- name: freq
  id: variable
  parameters:
    value: 852e6
  states: {}
- name: gui_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: tabs@0:0,0,1,1
    label: RX Gain
    start: '0'
    step: '1'
    stop: '49.6'
    value: '10.0'
  states: {}
- name: gui_samp_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: tabs@0:0,1,1,1
    label: SAMPLE RATE
    labels: '[''1.02MHz'', ''1.54MHz'', ''1.79MHz'', ''1.92MHz'', ''2.05MHz'', ''2.16MHz'', ''2.56MHz'', ''2.88MHz'', ''3.2MHz'', ''5.0MHz'', ''10.0MHz'', ''15.0MHz'',''20MHz'', ''25.0MHz'', ''30.0MHz'', ''35.0MHz'', ''40.0MHz'', ''45.0MHz'', ''50.0MHz'', ''55.0MHz'']'
    num_opts: '0'
    options: '[1024000.0, 1536000.0, 1792000.0, 1920000.0, 2048000.0, 2160000.0, 2560000.0, 2880000.0, 3200000.0, 5000000.0, 10000000.0, 15000000.0,20000000.0, 25000000.0, 30000000.0, 35000000.0, 40000000.0, 45000000.0, 50000000.0, 55000000.0]'
    type: real
    value: '2048000.0'
  states: {}
- name: note
  id: variable_qtgui_entry
  parameters:
    gui_hint: tabs@0:1,1,1,2
    label: RECORDING NOTE (press enter to update)
    type: string
    value: RECORDING_NOTE
  states: {}
- name: rec_button
  id: variable_qtgui_push_button
  parameters:
    gui_hint: tabs@0:1,3,1,1
    label: RECORD
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: record_file_path
  id: variable
  parameters:
    comment: set path to IQ recording directory
    value: '"data/"'
  states: {}
- name: rootdir
  id: variable
  parameters:
    comment: defaults to your users home directory
    value: str(os.path.expanduser("~")+"/")
  states: {}
- name: str_freq
  id: variable
  parameters:
    value: str(freq)
  states: {}
- name: timestamp
  id: variable
  parameters:
    comment: |-
      gets system time and
      applies string formatting
    value: datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S')
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: filename+str(datetime.fromtimestamp(time.time()).strftime('%Y_%m_%d_%H:%M:%S'))+".cfile" if rec_button == 1 else "/dev/null"
    type: complex
  states: {}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: freq
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: gui_samp_rate
    gui_hint: tabs@0:2,0,5,4
  states: {state: disabled}
- name: import_datetime
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: import_os
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_time
  id: import
  parameters:
    imports: import time
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: tabs@0:1,0,1,1
    key: freq
    label: Freq
    type: float
    value: str(freq)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: gui_samp_rate
    fc: freq
    fftsize: '8192'
    gui_hint: tabs@0:2,0,5,4
    showports: 'True'
    type: complex
    update_time: '0.05'
  states: {}
- name: qtgui_ledindicator_0
  id: qtgui_ledindicator
  parameters:
    gui_hint: tabs@0:0,3,1,1
    label: '"RED=RECORDING"'
    offColor: green
    onColor: red
    position: '2'
    state: True if rec_button == 1 else False
  states: {}
- name: rf_bw
  id: parameter
  parameters:
    label: RF BANDWITDH
    short_id: b
    type: eng_float
    value: 20e6
  states: {}
- name: rf_freq
  id: parameter
  parameters:
    label: RF FREQUENCY
    short_id: f
    type: eng_float
    value: 1534e6
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF GAIN
    short_id: g
    type: eng_float
    value: '40.0'
  states: {}
- name: samp_rate_0
  id: parameter
  parameters:
    label: SAMPLE RATE (choose from [1024000.0, 1536000.0, 1792000.0, 1920000.0, 2048000.0, 2160000.0, 2560000.0, 2880000.0, 3200000.0, 5000000.0, 10000000.0, 15000000.0,20000000.0, 25000000.0, 30000000.0, 35000000.0, 40000000.0, 45000000.0, 50000000.0, 55000000.0])
    short_id: s
    type: eng_float
    value: '2048000'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    dev_args: biastee=True
    gain: gui_gain
    samp_rate: gui_samp_rate
    type: fc32
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,7,4
    label0: Tab 0
    num_tabs: '1'
  states: {}

connections:
- [fosphor_qt_sink_c_0, freq, qtgui_edit_box_msg_0_0, val]
- [qtgui_edit_box_msg_0_0, msg, blocks_msgpair_to_var_0, inpair]
- [qtgui_edit_box_msg_0_0, msg, qtgui_freq_sink_x_0, freq]
- [qtgui_freq_sink_x_0, freq, qtgui_edit_box_msg_0_0, val]
- [soapy_rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', fosphor_qt_sink_c_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0-rc1
